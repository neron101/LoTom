## config/boards/shields/lotom/Kconfig.shield
```kconfig
config SHIELD_LOTOM_R
    def_bool $(shields_list_contains,lotom_R)

config SHIELD_LOTOM_L
    def_bool $(shields_list_contains,lotom_L)
```
